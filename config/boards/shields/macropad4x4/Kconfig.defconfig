## config/boards/shields/macropad4x4/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD4X4

config ZMK_KEYBOARD_NAME
    default "Macropad4x4"

endif
```
